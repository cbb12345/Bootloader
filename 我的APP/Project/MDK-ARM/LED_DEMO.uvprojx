# Keil uVision project LED_DEMO.uvprojx, settings and files
target LED_DEMO (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LED +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F051
  c include: ..\..\Libraries\CMSIS\ST\STM32F0xx\Source\Templates\arm;..\..\Libraries\CMSIS\ST\STM32F0xx\Include;..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\Project;..\..\BSP;..\..\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8005000 size 0xb000
  memory RVCT9: RAM 0x200000b4 size 0x1f4c
  group Startup
    ../../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
  group StdPeriph_Driver
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group CMSIS
    ../../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group BSP
    ../../BSP/: led.c usart1.c stmflash.c
  group Doc
    ../../doc/: readme.txt
  group User
    ../: main.c stm32f0xx_it.c
software components: CMSIS:CORE 4.1.0
