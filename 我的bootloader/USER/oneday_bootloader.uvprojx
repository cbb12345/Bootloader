# Keil uVision project oneday_bootloader.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: oneday_bootloader +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\CORE;..\HARDWARE;..\STM32_F0Lib\inc;..\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./: system_stm32f0xx.c
  group CORE
    ../CORE/: startup_stm32f0xx.s core_cm0.h
  group STM32_F0Lib
    ../STM32_F0Lib/src/: stm32f0xx_crc.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_misc.c stm32f0xx_flash.c
    ./: main.c
  group HARDWARE
    ../HARDWARE/: usart.c flash_if.c led.c menu.c ymodem.c aes.c
